# Repository ryood/FV-1

## KiCad design KiCAD/FV-1_Interface/FV-1_Interface.kicad_pcb

Parts:
C1, C5: 47u; CP_Radial_D5.0mm_P2.50mm
C6: 10p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7, C9: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
C8: 0.1u; C_Rect_L7.0mm_W3.5mm_P5.00mm
C10: 0.22u; C_Rect_L7.0mm_W3.5mm_P5.00mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: PWR; PinHeader_1x03_P2.54mm_Vertical
J2: TP_GND; PinHeader_1x02_P2.54mm_Vertical
J4: IN; PinHeader_1x02_P2.54mm_Vertical
J5: OUT; PinHeader_1x02_P2.54mm_Vertical
J6: FX_OUT; PinHeader_1x02_P2.54mm_Vertical
J7: FX_IN; PinHeader_1x02_P2.54mm_Vertical
R4, R8: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 50k/A; PinHeader_1x03_P2.54mm_Vertical
RV2: 50k/B; PinHeader_1x03_P2.54mm_Vertical
U2: TL072; DIP-8_W7.62mm

Connections:
+12V: C1.1, C7.2, J1.1, U2.8 (V+)
-12V: C5.2, C9.2, J1.3, U2.4 (V-)
GND: C1.2, C5.1, C7.1, C9.1, J1.2, J2.1, J2.2, J4.2, J5.2, J6.2, J7.2, RV1.1, U2.3 (+), U2.5 (+)
unnamed: C6.1, J6.1, R4.1, RV2.3, U2.1
unnamed: C6.2, R4.2, R6.1, U2.2 (-)
unnamed: C8.1, R6.2
unnamed: C8.2, RV1.2
unnamed: C10.1, RV2.1
unnamed: C10.2, J7.1
unnamed: J4.1, RV1.3
unnamed: J5.1, R7.1
unnamed: R5.1, R7.2, U2.7
unnamed: R5.2, R8.1, U2.6 (-)
unnamed: R8.2, RV2.2

Board: 2 copper layers, 71.1 x 45.7 mm, 25 parts (0 on the bottom side), 14 nets.

## KiCad design KiCAD/FV-1_Test_Board/FV-1_Test_Board.kicad_pcb

Parts:
C1: 100u; CP_Radial_D6.3mm_P2.50mm
C2, C4, C6: 1u; C_Rect_L7.0mm_W4.5mm_P5.00mm
C3, C5: 2200p; C_Rect_L7.0mm_W3.5mm_P5.00mm
C7: 0.047uF; C_Rect_L7.0mm_W3.5mm_P5.00mm
C8: 0.1u; C_Rect_L7.0mm_W3.5mm_P5.00mm
D1: LED; LED_D3.0mm
D2, D3: 1S4; D_DO-35_SOD27_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: PWR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: LOUT; PinHeader_1x02_P2.54mm_Vertical
J3: ROUT; PinHeader_1x02_P2.54mm_Vertical
J4: IN; PinHeader_1x02_P2.54mm_Vertical
J5: TP_GND; PinHeader_1x02_P2.54mm_Vertical
J6: S0; PinHeader_1x02_P2.54mm_Vertical
J7: S1; PinHeader_1x02_P2.54mm_Vertical
J8: S2; PinHeader_1x02_P2.54mm_Vertical
R1: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R4: 1k C&T; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R5: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV2, RV3: 50k/B; PinHeader_1x03_P2.54mm_Vertical
U1: AE-FV-1-DIP_large; DIP-18_W15.24mm

Connections:
+3V3: C1.1, D2.1, J1.1, R1.1, RV1.3, RV2.3, RV3.3, U1.5 (AVDD), U1.6 (DVDD), U1.13 (DVDD)
GND: C1.2, C3.2, C5.2, C7.2, C8.2, D1.1 (K), D3.2, J1.2, J2.2, J3.2, J4.2, J5.1, J5.2, J6.2, J7.2, J8.2, R3.1, R5.1, RV1.1, RV2.1, RV3.1, U1.4 (GND), U1.7 (T0)
unnamed: C2.1, R2.2, R3.2
unnamed: C2.2, U1.18 (LOUT)
unnamed: C3.1, J2.1, R2.1
unnamed: C4.1, R4.2, R5.2
unnamed: C4.2, U1.17 (ROUT)
unnamed: C5.1, J3.1, R4.1
unnamed: C6.1, R6.2
unnamed: C6.2, J4.1
unnamed: C7.1, D2.2, D3.1, R6.1, U1.1 (LIN), U1.2 (RIN)
unnamed: C8.1, U1.3 (MID)
unnamed: D1.2 (A), R1.2
unnamed: J6.1, U1.10 (S0)
unnamed: J7.1, U1.11 (S1)
unnamed: J8.1, U1.12 (S2)
unnamed: RV1.2, U1.14 (POT0)
unnamed: RV2.2, U1.15 (POT1)
unnamed: RV3.2, U1.16 (POT2)

Board: 2 copper layers, 94.0 x 71.1 mm, 33 parts (0 on the bottom side), 19 nets.

## Commit log

2021-09-06 Interface Board
2022-01-19 milestone
2022-02-02 FV-1 Interface module
2022-02-07 Combined test
